# Repository FaBoPlatform/Shinobi

## EAGLE design base/shinobi_BLE_Rev010001.brd

Parts:
ANALOG: FABO_BRICK_3PIN-S03B-PASK-2_LONG; FABO_BRICK_3PIN_S03B-PASK-2_LONG
BAT: S2B-PH-SM4_TB; S2B-PH-SM4-TB
C2: 1uf; 0603
C4, C5: 12pf; 0603
C7: 10uf; 0603
CY1: CRYSTAL-ABS07; ABRACON-ABS07-32.768KHZ
I2C: FABO_BRICK_I2C-S04B-PASK-2_LONG; FABO_BRICK_I2C_S04B-PASK-2_LONG
L1: 10uH; 0603
L2: LQW18AN15NJ00D; 0603
LED1: LED-0603; 0603
R2: RESISTOR-0603; 0603
R3, R4: 4.7K; 0603
SERIAL: FABO_BRICK_SERIAL-S04B-PASK-2_LONG; FABO_BRICK_SERIAL_S04B-PASK-2_LONG
SWD: PIN-HEADER-SMT(1.27MM)2X5
U$2: RAYTAC-MDBT42
U$5: SWICTH-4P(KMR2); SWITCH-4P(KMR2)

Connections:
+3V3: ANALOG.VCC, BAT.2 (1), C7.2, I2C.VCC, R3.2, R4.2, SERIAL.VCC, SWD.1, U$2.11 (VDD1)
DCC: L1.2, U$2.10 (DCC)
DEC4: C2.2, L2.1, U$2.9 (DEC4)
GND: ANALOG.GND, BAT.1 (2), C2.1, C4.1, C5.1, C7.1, I2C.GND, LED1.CATHODE, SERIAL.GND, SWD.3, SWD.5, SWD.9, U$2.1 (GND1), U$2.12 (GND2), U$2.24 (GND3), U$2.39 (GND4), U$5.3, U$5.4
unnamed: LED1.ANODE, R2.1
unnamed: L1.1, L2.2
unnamed: C5.2, CY1.P$2, U$2.13 (P0.00/XL1)
unnamed: C4.2, CY1.P$1, U$2.14 (P0.01/XL2)
P0.02: U$2.15 (P0.02)
P0.03: ANALOG.I/O, U$2.16 (P0.03)
P0.04: U$2.17 (P0.04)
P0.05: U$2.18 (P0.05)
P0.06: SERIAL.TX, U$2.19 (P0.06)
P0.07: U$2.20 (P0.07)
P0.08: SERIAL.RX, U$2.21 (P0.08)
P0.09: U$2.22 (P0.09)
P0.10: U$2.23 (P0.10)
P0.11: U$2.25 (P0.11)
P0.12: U$2.26 (P0.12)
P0.13: U$2.27 (P0.13)
P0.14: U$2.28 (P0.14)
P0.15: U$2.29 (P0.15)
P0.16: U$2.30 (P0.16), U$5.1, U$5.2
P0.17: U$2.31 (P0.17)
P0.18: R2.2, U$2.32 (P0.18)
P0.19: U$2.33 (P0.19)
P0.20: U$2.34 (P0.20)
P0.22: U$2.38 (P0.22)
P0.23: U$2.41 (P0.23)
P0.24: U$2.40 (P0.24)
P0.25: U$2.2 (P0.25)
P0.26: I2C.SDA, R4.1, U$2.3 (P0.26)
P0.27: I2C.SCL, R3.1, U$2.4 (P0.27)
P0.28: U$2.5 (P0.28)
P0.29: U$2.6 (P0.29)
P0.30: U$2.7 (P0.30)
P0.31: U$2.8 (P0.31)
RESET: SWD.10, U$2.35 (P0.21/RESET)
SWCLK: SWD.4, U$2.36 (SWDCLK)
SWDIO: SWD.2, U$2.37 (SWDIO)

Notes on the sheet:
Push Button
MDBT42
LED
Debug
DCDC
Analog
I2C
SERIAL
LiPo
1.0.1

Board: 2 copper layers, 40.5 x 35.0 mm, 20 parts (0 on the bottom side), 18 nets.

Other parts of the board:
U$1: FABO-SHINOBI
U$7: LOGO_FABO_M

## EAGLE design motor/shinobi_pwm_alpha.brd

Parts:
A0, A1, A2, A3, A4, A5: SJ
C1: 1uF; 0603
C2: 0.01uF; 0603
C3: 2.2uF; 0603
C9, C11, C13, C14: 10uF; 0603
C12, C15: 0.1uF; 0603
CAP: PINHD-1X1; 1X01
D1, D2: MBR0520L; MBR0502L
FABO_I2C_PORT: FABO-I2C_BM04B; I2C-BM04B-PASS-1
GND: PINHD-1X1; 1X01
IC1: LP2985-33DBV; SOT-23-5
OE: PINHD-1X1; 1X01
PCA9685: PCA9685
PWM0, PWM1, PWM2, PWM3, PWM4, PWM5, PWM6, PWM7, PWM8, PWM9, PWM10, PWM11, PWM12, PWM13, PWM14, PWM15: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
R1, R2, R3, R6: 220; EXBV8V
R4, R5: 10k; EXBV8V
R7, R10: 4.7K; R0402
R15: 300K; 0603
R16: 1Ω; 0603
R17: 150K; 0603
SSM6J216FE: SSM6J216FE
U1: SN6501DBVR; SOT-23-5
U$5: ML-1400-S1
U$6: 760390014
U$8: TPS76333
U$18: ISO1541

Connections:
0: C1.1, C2.1, C3.1, C12.1, C13.1, FABO_I2C_PORT.GND, IC1.2 (GND), U1.4 (GND), U1.5 (GND), U$18.GND1
GND: C9.1, C14.2, C15.2, GND.1, PCA9685.14 (VSS), PWM0.GND, PWM1.GND, PWM2.GND, PWM3.GND, PWM4.GND, PWM5.GND, PWM6.GND, PWM7.GND, PWM8.GND, PWM9.GND, PWM10.GND, PWM11.GND, PWM12.GND, PWM13.GND, PWM14.GND, PWM15.GND, R4.1, R4.2 (1), R4.3 (1), R4.4 (1), R5.1, R5.2 (1), R5.3 (1), R5.4 (1), R16.2, R17.1, SSM6J216FE.3 (GATE), U$5.LEFT1 (PIN1), U$5.LEFT2 (PIN1), U$6.5, U$8.GND, U$18.GND2
unnamed: OE.1, PCA9685.23 (OE), R4.8 (2)
unnamed: PCA9685.25 (EXTCLK), R4.7 (2)
unnamed: A0.2, PCA9685.1 (A0), R4.6 (2)
unnamed: A1.2, PCA9685.2 (A1), R4.5 (2)
unnamed: A2.2, PCA9685.3 (A2), R5.8 (2)
unnamed: A3.2, PCA9685.4 (A3), R5.7 (2)
unnamed: A4.2, PCA9685.5 (A4), R5.6 (2)
unnamed: A5.2, PCA9685.24 (A5), R5.5 (2)
unnamed: PCA9685.6 (LED0), R1.4 (1)
unnamed: PCA9685.7 (LED1), R1.3 (1)
unnamed: PCA9685.8 (LED2), R1.2 (1)
unnamed: PWM4.I/O, R2.5 (2)
unnamed: PCA9685.10 (LED4), R2.4 (1)
unnamed: PCA9685.11 (LED5), R2.3 (1)
unnamed: PCA9685.12 (LED6), R2.2 (1)
unnamed: PCA9685.13 (LED7), R2.1
unnamed: PCA9685.9 (LED3), R1.1
unnamed: PCA9685.16 (LED9), R3.3 (1)
unnamed: PCA9685.17 (LED10), R3.2 (1)
unnamed: PCA9685.18 (LED11), R3.1
unnamed: PCA9685.19 (LED12), R6.4 (1)
unnamed: PCA9685.20 (LED13), R6.3 (1)
unnamed: PCA9685.21 (LED14), R6.2 (1)
unnamed: PCA9685.22 (LED15), R6.1
unnamed: PWM11.I/O, R3.8 (2)
unnamed: C11.1, R16.1
unnamed: A0.1, A1.1, A2.1, A3.1, A4.1, A5.1, C9.2, C11.2, PCA9685.28 (VDD), R7.2, R10.2, R15.2, U$8.OUT, U$18.VCC2
unnamed: SSM6J216FE.1 (DRAIN1), SSM6J216FE.2 (DRAIN2), SSM6J216FE.5 (DRAIN3), SSM6J216FE.6 (DRAIN4), U$5.RIGHT1 (PIN2), U$5.RIGHT2 (PIN2)
unnamed: C1.2, C12.2, C13.2, FABO_I2C_PORT.5V (VCC), IC1.1 (VIN), IC1.3 (ON/OFF), U1.2 (VCC), U$6.2
unnamed: PWM0.I/O, R1.5 (2)
unnamed: PWM1.I/O, R1.6 (2)
unnamed: PWM2.I/O, R1.7 (2)
unnamed: PCA9685.15 (LED8), R3.4 (1)
unnamed: PWM3.I/O, R1.8 (2)
unnamed: PWM5.I/O, R2.6 (2)
unnamed: PWM6.I/O, R2.7 (2)
unnamed: PWM7.I/O, R2.8 (2)
unnamed: PWM8.I/O, R3.5 (2)
unnamed: PWM9.I/O, R3.6 (2)
unnamed: PWM10.I/O, R3.7 (2)
unnamed: PWM12.I/O, R6.5 (2)
unnamed: PWM13.I/O, R6.6 (2)
unnamed: PWM14.I/O, R6.7 (2)
unnamed: PWM15.I/O, R6.8 (2)
unnamed: D1.P$2, U$6.6
unnamed: U1.3 (D2), U$6.1
unnamed: U1.1 (D1), U$6.3
unnamed: C14.1, C15.1, D1.P$1, D2.P$1, U$8.EN, U$8.IN
unnamed: D2.P$2, U$6.4
unnamed: C2.2, IC1.4 (BYPASS)
unnamed: C3.2, IC1.5 (VOUT), U$18.VCC1 (VCC)
unnamed: R15.1, R17.2, U$8.NC/FB
SCL1: FABO_I2C_PORT.SCL, U$18.SCL1
SCL2: PCA9685.26 (SCL), R7.1, U$18.SCL2
SDA1: FABO_I2C_PORT.SDA, U$18.SDA1
SDA2: PCA9685.27 (SDA), R10.1, U$18.SDA2
VCC: CAP.1, PWM0.VCC, PWM1.VCC, PWM2.VCC, PWM3.VCC, PWM4.VCC, PWM5.VCC, PWM6.VCC, PWM7.VCC, PWM8.VCC, PWM9.VCC, PWM10.VCC, PWM11.VCC, PWM12.VCC, PWM13.VCC, PWM14.VCC, PWM15.VCC, SSM6J216FE.4 (SOURCE)

Notes on the sheet:
GPIO/Servo (3pin Top 2.54mm pitch) x5
1.0.1
3.3V

Board: 2 copper layers, 40.5 x 35.0 mm, 58 parts (14 on the bottom side), 59 nets.

Other parts of the board:
U$1: FABO-SHINOBI
U$2: LOGO_FABO_S

## EAGLE design environment/shinobi_environment.brd

Parts:
B1: BO-BME680; BOSCH-BME680
C1, C8: 100nf; 0603
C2, C5: 1uF; 0603
C3, C7: 0.1uF; 0603
C4: 0.01uF; 0603
C6: 4.7uF; 0603
I2C: FABO_BRICK_I2C-S04B-PASK-2_LONG; FABO_BRICK_I2C_S04B-PASK-2_LONG
IC1: IN-ISL29034; INTERSIL-ISL29034
IC2: LP2985-33DBV; SOT-23-5
IC3: SILICONLABS-SI1133
INT: TPB1,27; B1,27
R1: 100; 0603
R2: 10k; 0603
R3: 200k; 0603
R5, R6: 4.7k; 0603
SJ1: SJ2W; SJ_2
SJ2: SJ
TP1, TP2, TP3: TPB1,27; B1,27
U4: PCA9306DP1; TSSOP8
U$2: CUS05F40

Connections:
5V: I2C.VCC, SJ1.1, SJ2.1, U$2.A (ANODE)
+3V3: B1.2 (CSB), B1.6 (VDDIO), B1.8 (VDD), C1.2, C3.2, C6.2, C8.2, IC2.5 (VOUT), IC3.3 (VDD), IC3.6 (AD), IC3.7 (RPU), IC3.9 (RPU), R1.2, R2.2, R5.2, R6.2, SJ1.3, SJ2.2, TP3.TP, U4.VREF1
GND: B1.1 (GND), B1.5 (SDO), B1.7 (GND), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, I2C.GND, IC1.2 (GND), IC2.2 (GND), IC3.8 (GND), U4.GND
unnamed: C4.2, IC2.4 (BYPASS)
unnamed: C5.2, IC2.1 (VIN), IC2.3 (ON/OFF), U$2.C (CATHODE)
unnamed: IC3.4 (INT), INT.TP, R2.1
unnamed: C7.2, R3.1, U4.EN, U4.VREF2
unnamed: R3.2, SJ1.2
SCL: B1.4 (SCK), IC1.3 (SCL), IC3.2 (SCL), R5.1, U4.SCL1
SCL_HV: I2C.SCL, TP1.TP, U4.SCL2
SDA: B1.3 (SDI), IC1.4 (SDA), IC3.1 (SDA), R6.1, U4.SDA1
SDA_HV: I2C.SDA, TP2.TP, U4.SDA2
VCC: C2.2, IC1.1 (VCC), R1.1

Notes on the sheet:
BME680
-33
※デフォルトで1-2に半田すること
※VCCが3.3Vの時使用、通常は使用しないこと
Si1132

Board: 2 copper layers, 40.5 x 35.0 mm, 28 parts (0 on the bottom side), 13 nets.

Other parts of the board:
U$3: FABO-SHINOBI
U$14: LOGO_FABO_MS

## EAGLE design base/shinobi_BLE_connector.brd

Parts:
C1, C3, C6: 0.1uF; 0603
C2: 1uf; 0603
C4, C5: 12pf; 0603
CY1: 32KHz; ABRACON-ABS07-32.768KHZ
L1: 10uh; 0603
L2: 15nh; 0603
LED1: LED-0603; 0603
P1: MF-NSML600-2; 1206
R2: 220; 0603
S1: AMS1117; SOT-223-3
U$2: RAYTAC-MDBT42
U$4: PIN-HEADER-SMT(1.27MM)2X5
U$5: SWICTH-4P(KMR2); SWITCH-4P(KMR2)
USB1: USB-MICRO_B_SMT_HIROSE; ZX62R-B-5P
X1: FH12-08S-1SH

Connections:
5V: C1.2, S1.3 (IN), USB1.1 (VBUS)
+3V3: C6.2, P1.P$2 (2), U$2.11 (VDD1), U$4.1, X1.2
DCC: L1.2, U$2.10 (DCC)
DEC4: C2.2, L2.1, U$2.9 (DEC4)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, LED1.CATHODE, S1.1 (ADJ), U$2.1 (GND1), U$2.12 (GND2), U$2.24 (GND3), U$2.39 (GND4), U$4.3, U$4.5, U$4.9, U$5.3, USB1.5 (GND), X1.1
unnamed: LED1.ANODE, R2.1
unnamed: L1.1, L2.2
unnamed: C3.2, P1.P$1 (1), S1.2 (OUT)
unnamed: C5.2, CY1.P$2, U$2.13 (P0.00/XL1)
unnamed: C4.2, CY1.P$1, U$2.14 (P0.01/XL2)
P0.02: U$2.15 (P0.02), X1.3
P0.03: U$2.16 (P0.03), X1.4
P0.04: U$2.17 (P0.04), X1.5
P0.05: U$2.18 (P0.05), X1.6
P0.06: U$2.19 (P0.06)
P0.07: U$2.20 (P0.07)
P0.08: U$2.21 (P0.08)
P0.09: U$2.22 (P0.09)
P0.10: U$2.23 (P0.10)
P0.11: U$2.25 (P0.11)
P0.12: U$2.26 (P0.12)
P0.13: U$2.27 (P0.13)
P0.14: U$2.28 (P0.14)
P0.15: U$2.29 (P0.15)
P0.16: U$2.30 (P0.16), U$5.2
P0.17: U$2.31 (P0.17)
P0.18: R2.2, U$2.32 (P0.18)
P0.19: U$2.33 (P0.19)
P0.20: U$2.34 (P0.20)
P0.22: U$2.38 (P0.22)
P0.23: U$2.41 (P0.23)
P0.24: U$2.40 (P0.24)
P0.25: U$2.2 (P0.25)
P0.26: U$2.3 (P0.26)
P0.27: U$2.4 (P0.27)
P0.28: U$2.5 (P0.28), X1.7
P0.29: U$2.6 (P0.29), X1.8
P0.30: U$2.7 (P0.30)
P0.31: U$2.8 (P0.31)
RESET: U$2.35 (P0.21/RESET)
RESET1: U$4.10
SWCLK: U$2.36 (SWDCLK), U$4.4
SWDIO: U$2.37 (SWDIO), U$4.2

Notes on the sheet:
Push Button
MDBT42
LED
Debug
DCDC
Connector
Supply
USB

Board: 2 copper layers, 40.5 x 35.0 mm, 20 parts (0 on the bottom side), 20 nets.

Other parts of the board:
U$1: FABO-SHINOBI
U$3: LOGO_FABO_S

## EAGLE design sensor/CO2SensorRev01(CDM7160).brd

Parts:
ALARM: LEDCHIPLED_0603; CHIPLED_0603
ANA: 22-23-2021
BAT: FABO_BRICK_2PIN_SIDE; FABO_BRICK_2PIN_S02B−PASK-2_SILK
BUSY: LEDCHIPLED_0603; CHIPLED_0603
C1, C6, C9: 1uf; 0603
C2: 2.2uf; 0603
C3: 0.01uf; 0603
C4: 22uF; 0805
C5, C8, C10: 10uF; 0805
C7: 0.1uf; 0603
D1: BZT52C5V1-7-F; SOD123
D3: DF2B7ACT
F1: MF-USMF075
IC1: LP2985-33DBV; SOT-23-5
IC2: TPS63000; DRC-S-PVSON-N10
IC3: PCA9515; SO8
IC4: LM358D; SO08
J1: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
JMP1, JMP2, JMP3, JMP4, JMP5, JMP6, JMP7: 0R-JUMPA; A0R-JMP
JP1: PINHD-1X5; 1X05
JP2: 1; 1X06
L1: VLF4012AT-2R2M1R5; VLF4012A
POWER: LEDCHIPLED_0603; CHIPLED_0603
R1: 100; 0603
R2: 4.7M; 0603
R3: 523; 0603
R4, R5: 4.7K; 0603
R6, R7: 10K; 0603
R8, R9: 100K; 0603
R10: 470; 0603
R11, R12: 1K; 0603
SJ1: SJW
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15: TPTP11R; TP11R
U$1, U$3, U$7, U$8, U$9, U$11: DF2B7ACT

Connections:
GND: ALARM.C, ANA.2, BAT.GND, C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, D1.C, D3.P$2 (2), IC1.2 (GND), IC2.3 (PGND), IC2.7 (PS/SYNC), IC2.9 (GND), IC2.TH (PGND), IC3.4 (GND), IC4.4 (V-), J1.GND, JMP2.3, JMP6.3, JP1.2, POWER.C, R3.1, R12.1, TP10.TP, U$1.P$2 (2), U$3.P$2 (2), U$7.P$2 (2), U$8.P$2 (2), U$9.P$2 (2), U$11.P$2 (2)
unnamed: IC3.2 (SCL0), J1.SCL, TP6.TP
unnamed: IC3.3 (SDA0), J1.SDA, TP7.TP
unnamed: D3.P$1 (1), IC3.7 (SCL1), JP2.2, R4.2, TP4.TP
unnamed: IC3.6 (SDA1), JP2.3, R5.2, TP5.TP, U$3.P$1 (1)
unnamed: C1.2, IC1.1 (VIN), IC1.3 (ON/OFF), JMP5.2, JMP7.3, TP8.TP
unnamed: F1.P$2, JMP5.1
unnamed: JMP2.2, R6.1
unnamed: IC3.5 (EN), JMP4.2
unnamed: C2.2, IC1.5 (VOUT), JMP4.3, JMP7.1, TP3.TP
unnamed: C3.2, IC1.4 (BYPASS)
unnamed: C6.2, IC2.6 (EN), IC2.8 (VINA), R1.1
unnamed: BAT.VCC, F1.P$1
unnamed: IC2.10 (FB), R2.1, R3.2
unnamed: C4.2, IC2.5 (VIN), J1.VCC, JMP3.1, JMP4.1, JMP5.3, R1.2, R10.2, TP2.TP
unnamed: IC2.4 (L1), L1.P$1 (1)
unnamed: IC2.2 (L2), L1.P$2 (2)
unnamed: C8.2, C10.2, IC2.1 (VOUT), JMP3.3, R2.2, TP1.TP
unnamed: JMP6.2, R7.1, U$7.P$1 (1)
unnamed: JP2.6, R7.2
unnamed: JP1.5, R6.2
unnamed: BUSY.A, JP2.4, TP13.TP, U$8.P$1 (1)
unnamed: JMP1.2, JP2.5, TP14.TP
unnamed: JP1.4, R8.1, TP12.TP, U$11.P$1 (1)
unnamed: JP1.3, R11.1, TP11.TP, U$1.P$1 (1)
unnamed: C9.2, IC4.3 (+IN), R8.2
unnamed: JMP1.1, TP15.TP
unnamed: POWER.A, R10.1
unnamed: ANA.1, R9.2
unnamed: IC4.1 (OUT), IC4.2 (-IN), R9.1
unnamed: ALARM.A, R11.2
unnamed: BUSY.C, R12.2
unnamed: IC3.8 (VCC), JMP7.2
unnamed: C5.2, C7.2, D1.A, JMP1.3, JMP2.1, JMP3.2, JMP6.1, JP1.1, R4.1, R5.1, SJ1.1, TP9.TP, U$9.P$1 (1)
unnamed: IC4.8 (V+), SJ1.2

Notes on the sheet:
RIGHT
PCA9515A
1.0.0A
CMD7160-C00
LEFT
OUTLET 5V
LP2985-33
JST 4pin PA
DF2B7ACT,L3F
VCC
GND
ALARM
PWM
CAD0
BUSY
SCL/RX
SDA/TX
CAL
MSEL
CAL EN
Address Select
Repeator Enable
USE LDO
OUTLET
I2C
UART
PWM to ANALOG
POW
3.3V
VOLTAGE SELECT
ANALOG OUTPUT
CAL DISABLE
I2C Repeator
VCC to 5V
VCC to 3.3V
BZT52C5V1-7-F

Notices in the files:
parts and their libraries:
FaBo-Inductor: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
